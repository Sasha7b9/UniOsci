# Keil uVision project Device.uvprojx, settings and files
target Device (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Device
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F437xx, __cplusplus
  c misc: --cpp
  c include: ..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Src;..\_libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\_libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include;..\_libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\system;..\_libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;..\_libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src;..\_libs\STM32Cube_F4\Drivers\CMSIS\Include;..\_libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Device;.\Device\libs;.\Device\Ethernet;.\Device\VCP
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device\Device54.sct
  group HAL
    ../_libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
  group USBD
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
  group USBH
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c
  group FatFS
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group LwIP
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c etharp.c ip4_frag.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c ip.c timeouts.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group STM32F437lib
    ../common/STM32F437lib/: GPIO.c GPIO.h GPIOdefs.h
  group libs
    ./Device/libs/: ffconf.h startup_stm32f437xx.s stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c usbh_conf.c usbh_conf.h _ffconf.h
  group src
    ./Device/: cmsis_gcc.h defines.c defines.h FileTree.txt Globals.c Globals.h Log.c Log.h main.c main.h main2.s Tables.c Tables.h
  group Data
    ./Device/Data/: Data.cpp Data.h DataSettings.c DataSettings.h DataStorage.cpp DataStorage.h
  group Display
    ./Device/Display/: Colors.cpp Colors.h Display.cpp Display.h DisplayPrimitives.c DisplayPrimitives.h DisplayTypes.h Grid.cpp Grid.h Math3D.c Math3D.h Painter.cpp Painter.h PainterData.cpp PainterData.h PainterMem.c PainterMem.h PainterText.cpp Symbols.h WelcomeScreen.c WelcomeScreen.h
  group Display/font
    ./Device/Display/font/: Font.c Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc
  group Ethernet
    ./Device/Ethernet/: app_ethernet.c app_ethernet.h Ethernet.c Ethernet.h ethernetif.c ethernetif.h lwipopts.h TcpSocket.c TcpSocket.h
  group FlashDrive
    ./Device/FlashDrive/: FlashDrive.c FlashDrive.h
  group FPGA
    ./Device/FPGA/: FPGA.c FPGA.h FPGAextensions.c FPGAextensions.h fpgaSettings.c FPGATypes.c fpgaTypes.h
  group Hardware
    ./Device/Hardware/: FLASH.c FLASH.h FSMC.c FSMC.h Hardware.c Hardware.h RAM.c RAM.h RTC.c RTC.h Sound.c Sound.h Timer.c Timer.h
  group Menu
    ./Device/Menu/: FileManager.cpp FileManager.h Menu.cpp Menu.h MenuDrawing.cpp MenuDrawing.h MenuFunctions.cpp MenuFunctions.h MenuItems.cpp MenuItems.h MenuItemsDefs.h MenuItemsGraphics.cpp MenuItemsLogic.cpp
  group Menu/Pages
    ./Device/Menu/Pages/: Definition.cpp Definition.h HelpContent.c HelpContent.h HelpContentPages.h PageChannels.c PageCursors.c PageCursors.h PageDebug.c PageDisplay.c PageDisplay.h PageHelp.c PageHelp.h PageMeasures.c PageMemory.c PageMemory.h PageService.c PageTime.c PageTrig.cpp
  group Panel
    ./Device/Panel/: Controls.c Controls.h Panel.cpp Panel.h PanelFunctions.h
  group SelfRecorder
    ./Device/SelfRecorder/: SelfRecorder.c SelfRecorder.h
  group Settings
    ./Device/Settings/: Settings.c Settings.h SettingsChannel.c SettingsChannel.h SettingsCursors.c SettingsCursors.h SettingsDebug.c SettingsDebug.h SettingsDisplay.c SettingsDisplay.h SettingsMath.h SettingsMeasures.h SettingsMemory.c SettingsMemory.h SettingsNRST.h SettingsService.c SettingsService.h SettingsTime.c SettingsTime.h SettingsTrig.h SettingsTypes.h
  group Utils
    ./Device/Utils/: Debug.c Debug.h Dictionary.c Dictionary.h Generator.c Generator.h GlobalFunctions.c GlobalFunctions.h Map.c Map.h Math.cpp Math.h Measures.cpp Measures.h ProcessingSignal.cpp ProcessingSignal.h Strings.c Strings.h TablesLog.h TablesWindow.h CreateTables.py
  group VCP
    ./Device/VCP/: usbd_cdc_interface.c usbd_cdc_interface.h usbd_conf.c usbd_conf.h usbd_core.c usbd_desc.c usbd_desc.h VCP.cpp VCP.h
  group VCP/SCPI
    ./Device/VCP/SCPI/: channelSCPI.c commonSCPI.c commonSCPI.h controlSCPI.c controlSCPI.h displaySCPI.c SCPI.c SCPI.h tbaseSCPI.c trigSCPI.c
