# Keil uVision project Device54.uvprojx, settings and files
target Device54 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Device
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F437xx, __cplusplus
  c misc: --cpp
  c include: ..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Src;..\_libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\_libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include;..\_libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\system;..\_libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;..\_libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src;..\_libs\STM32Cube_F4\Drivers\CMSIS\Include;..\_libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Device;.\Device\libs;.\Device\Ethernet;.\Device\VCP;..\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device\Device54.sct
  group HAL
    ../_libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
  group USBD
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
  group USBH
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c
  group FatFS
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group LwIP
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c etharp.c ip4_frag.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c ip.c timeouts.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group STM32F437lib
    ../common/STM32F437lib/: GPIO.c GPIO.h GPIOdefs.h
  group libs
    ./Device/libs/: ffconf.h startup_stm32f437xx.s stm32f4xx_hal_conf.h stm32f4xx_it.h system_stm32f4xx.c usbh_conf.h usbh_diskio.h stm32f4xx_hal_msp.cpp stm32f4xx_it.cpp usbd_conf.h usbh_conf.cpp usbh_diskio.cpp usbd_conf.cpp
  group src
    ./Device/: cmsis_gcc.h defines.h FileTree.txt Globals.h Log.h main.h main2.s Tables.h main.cpp Device54.sct Globals.cpp Log.cpp Tables.cpp
    ../common/: commonDefines.h commonDefines.cpp
  group Data
    ./Device/Data/: DataSettings.h DataStorage.cpp DataStorage.h DataSettings.cpp Reader.cpp Reader.h
  group Display
    ./Device/Display/: Display.cpp Display.h PainterData.cpp PainterData.h PainterMem.h PainterMem.cpp
    ../common/Display/: Colors.cpp Colors.h DisplayPrimitives.cpp DisplayPrimitives.h Grid.cpp Grid.h DisplayTypes.h Painter.cpp Painter.h PainterText.cpp Symbols.h
  group Display/Font
    ./Device/Display/font/: Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc Font.cpp
  group Ethernet
    ./Device/Ethernet/: app_ethernet.h Ethernet.h ethernetif.h lwipopts.h TcpSocket.h app_ethernet.cpp Ethernet.cpp ethernetif.cpp TcpSocket.cpp
  group FlashDrive
    ./Device/FlashDrive/: FlashDrive.h FlashDrive.cpp
  group FPGA
    ./Device/FPGA/: FPGA.h FPGAextensions.h fpgaTypes.h FPGA.cpp FPGAextensions.cpp fpgaSettings.cpp FPGATypes.cpp
    ../common/FPGA/: FPGAMath.cpp FPGAMath.h
  group Hardware
    ./Device/Hardware/: FLASH.h FSMC.h Hardware.h RAM.h RTC.h Sound.h Timer.h FLASH.cpp FSMC.cpp Hardware.cpp RAM.cpp RTC.cpp Sound.cpp Timer.cpp
  group Menu
    ./Device/Menu/: FileManager.cpp FileManager.h MenuPagesNames.h
    ../common/Menu/: MenuItems.cpp MenuItems.h MenuItemsLogic.cpp MenuFunctions.cpp MenuFunctions.h MenuItemsDefs.h Menu.cpp Menu.h MenuDrawing.cpp MenuDrawing.h MenuItemsGraphics.cpp
  group Menu/Pages
    ./Device/Menu/Pages/: HelpContent.h HelpContentPages.h PageCursors.h PageDisplay.h PageHelp.h PageMemory.h PageTrig.cpp PageCursors.cpp PageDebug.cpp PageDisplay.cpp PageHelp.cpp PageMeasures.cpp PageMemory.cpp PageService.cpp PageTime.cpp HelpContent.cpp PageChannels.cpp
    ../common/Menu/Pages/: Definition.cpp Definition.h
  group Panel
    ./Device/Panel/: Controls.h Panel.cpp Panel.h PanelFunctions.h Controls.cpp
  group SelfRecorder
    ./Device/SelfRecorder/: SelfRecorder.c SelfRecorder.h
  group Settings
    ./Device/Settings/: Settings.h SettingsChannel.h SettingsCursors.h SettingsDebug.h SettingsDisplay.h SettingsMath.h SettingsMeasures.h SettingsMemory.h SettingsNRST.h SettingsService.h SettingsTime.h SettingsTrig.h SettingsTypes.h Settings.cpp SettingsChannel.cpp SettingsCursors.cpp SettingsDebug.cpp SettingsDisplay.cpp SettingsMemory.cpp SettingsTime.cpp
    ../common/Settings/: commonSettings.cpp
  group Utils
    ./Device/Utils/: ProcessingSignal.cpp ProcessingSignal.h
    ../common/Utils/: Math.cpp Math.h StringUtils.cpp StringUtils.h Dictionary.cpp Dictionary.h Map.cpp Map.h Measures.cpp Measures.h
  group VCP
    ./Device/VCP/: usbd_cdc_interface.h usbd_desc.h VCP.cpp VCP.h usbd_cdc_interface.cpp usbd_core.cpp usbd_desc.cpp
  group VCP/SCPI
    ./Device/VCP/SCPI/: commonSCPI.h controlSCPI.h SCPI.h channelSCPI.cpp commonSCPI.cpp controlSCPI.cpp displaySCPI.cpp SCPI.cpp tbaseSCPI.cpp trigSCPI.cpp
