#include "Grid.h"
#include "Globals.h"
#include "Settings/Settings.h"


//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
int Grid::Left(void)
{
    return (MenuIsMinimize() && MENU_IS_SHOWN ? 9 : 20) + measures.GetDeltaGridLeft();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::Right(void)
{
    return ((MenuIsMinimize() && MENU_IS_SHOWN) ? 9 : 20) + 280;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::ChannelBottom(void)
{
    return (sDisplay_IsSeparate()) ? (GRID_TOP + GRID_HEIGHT / 2) : FullBottom();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::ChannelHeight(void)
{
    return (sDisplay_IsSeparate()) ? Grid::FullHeight() / 2 : Grid::FullHeight();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::ChannelCenterHeight(void)
{
    return (GRID_TOP + Grid::ChannelBottom()) / 2;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::FullBottom(void)
{
    return GRID_BOTTOM - measures.GetDeltaGridBottom();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::FullHeight(void)
{
    return Grid::FullBottom() - GRID_TOP;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::Width(void)
{
    return Grid::Right() - Grid::Left();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::FullCenterHeight(void)
{
    return (Grid::FullBottom() + GRID_TOP) / 2;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::WidthInCells(void)
{
    return MENU_IS_SHOWN ? 10 : 14;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
float Grid::DeltaY(void)
{
    float delta = (Grid::FullBottom() - GRID_TOP) / 10.0f;
    return sDisplay_IsSeparate() ? (delta / 2.0f) : delta;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
float Grid::DeltaX(void)
{
    float delta = (Grid::Right() - Grid::Left()) / 14.0f;
    return delta;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::MathTop(void)
{
    return Grid::MathBottom() - Grid::MathHeight();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::MathHeight(void)
{
    if (FFT_ENABLED || FUNC_MODE_DRAW_IS_SEPARATE)
    {
        return Grid::FullHeight() / 2;
    }
    return Grid::FullHeight();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::MathBottom(void)
{
    return Grid::FullBottom();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::BottomMessages(void)
{
    int retValue = Grid::FullBottom();
    if (MODE_WORK_IS_ROM)
    {
        retValue -= 12;
    }
    else if (SHOW_MEASURES)
    {
        retValue = TOP_MEASURES;
    }
    return retValue - 12;;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
void Grid::CoordTrigLevel(int *left, int *top, int width)
{
    if (!SHOW_MEASURES || NUM_MEASURES < MN_6_1)
    {
        *left = (Grid::Width() - width) / 2 + Grid::Left();
        *top = BottomMessages() - 20;
    }
    else
    {
        *left = NUM_MEASURES_IS_6_1 ? 100 : 130;
        *top = Grid::FullBottom() - 32;
    }
}
