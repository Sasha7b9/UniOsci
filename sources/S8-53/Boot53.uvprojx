# Keil uVision project Boot53.uvprojx, settings and files
target Boot53 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F217IGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: S8-53
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F207xx, __cplusplus, S8_53
  c misc: --cpp
  c include: ..\_libs\STM32Cube_F2\Drivers\CMSIS\Include;..\_libs\STM32Cube_F2\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\_libs\STM32Cube_F2\Drivers\STM32F2xx_HAL_Driver\Inc;..\_libs\STM32Cube_F2\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\_libs\STM32Cube_F2\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\_libs\STM32Cube_F2\Middlewares\Third_Party\FatFs\src;..\_libs\STM32Cube_F2\Middlewares\Third_Party\FatFs\src\drivers;.\Boot53;.\Boot53\libs;..\common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Boot53\Boot53.sct
  group Display
    ./Boot53/Display/: Colors.h Display.h DisplayTypes.h Painter.h PainterC.h PainterText.h Colors.cpp Display.cpp Painter.cpp PainterText.cpp
  group FatFS
    ../_libs/STM32Cube_F2/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../_libs/STM32Cube_F2/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ../_libs/STM32Cube_F2/Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c usbh_diskio.h
  group FlashDrive
    ./Boot53/FlashDrive/: FlashDrive.h FlashDrive.cpp
  group HAL
    ../_libs/STM32Cube_F2/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hcd.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_usb.c stm32f2xx_hal_spi.c
  group Hardware
    ./Boot53/Hardware/: FLASH.h FSMC.h Hardware.h Timer.h FLASH.cpp FSMC.cpp Hardware.cpp Timer.cpp
  group libs
    ./Boot53/libs/: ffconf.h startup_stm32f207xx.s stm32f2xx_hal_conf.h stm32f2xx_it.h system_stm32f2xx.c usbh_conf.h stm32f2xx_hal_msp.cpp stm32f2xx_it.cpp usbh_conf.cpp
  group Panel
    ./Boot53/Panel/: Controls.h Panel.h Controls.cpp Panel.cpp
  group Settings
    ./Boot53/Settings/: Settings.h SettingsTypes.h Settings.cpp
  group src
    ./Boot53/: Boot53.sct defines.h globals.h main.h globals.cpp main.cpp
    ../common/: commonDefines.cpp commonDefines.h
  group USBH
    ../_libs/STM32Cube_F2/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../_libs/STM32Cube_F2/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Utils
    ../common/Utils/: StringUtils.cpp StringUtils.h Dictionary.cpp Dictionary.h Math.cpp Math.h
  group Display/fonts
    ./Boot53/Display/font/: Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc Font.cpp
  group FPGA
    ./Boot53/FPGA/: FPGATypes.h
