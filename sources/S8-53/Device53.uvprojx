# Keil uVision project Device53.uvprojx, settings and files
target Device53 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F217IGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Device53
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F207xx, __cplusplus, S8_53
  c misc: --cpp
  c include: ..\_libs\STM32Cube_F2\Drivers\CMSIS\Include;..\_libs\STM32Cube_F2\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\_libs\STM32Cube_F2\Drivers\STM32F2xx_HAL_Driver\Inc;..\_libs\STM32Cube_F2\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\_libs\STM32Cube_F2\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\_libs\STM32Cube_F2\Middlewares\Third_Party\FatFs\src;..\_libs\STM32Cube_F2\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\_libs\STM32Cube_F2\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\_libs\STM32Cube_F2\Middlewares\Third_Party\LwIP\src\include;..\_libs\STM32Cube_F2\Middlewares\Third_Party\LwIP\system;..\_libs\STM32Cube_F2\Middlewares\Third_Party\FatFs\src\drivers;.\Device53;.\Device53\libs;..\common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Device53\Device53.sct
  group HAL
    ../_libs/STM32Cube_F2/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hcd.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_usb.c
  group USBH
    ../_libs/STM32Cube_F2/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../_libs/STM32Cube_F2/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group LwIP
    ../_libs/STM32Cube_F2/Middlewares/Third_Party/LwIP/src/core/: udp.c tcp_in.c tcp_out.c tcp.c sys.c stats.c raw.c pbuf.c netif.c memp.c mem.c init.c dns.c inet_chksum.c def.c ip.c timeouts.c
    ../_libs/STM32Cube_F2/Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip4.c igmp.c icmp.c autoip.c dhcp.c etharp.c ip4_frag.c
    ../_libs/STM32Cube_F2/Middlewares/Third_Party/LwIP/src/api/: tcpip.c sockets.c netdb.c netbuf.c err.c api_msg.c api_lib.c
    ../_libs/STM32Cube_F2/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group libs
    ./Device53/libs/: app_ethernet.h ethernetif.h ffconf.h lwipopts.h startup_stm32f207xx.s stm32f2xx_hal_conf.h stm32f2xx_it.h system_stm32f2xx.c usbd_cdc_interface.h usbd_conf.h usbd_desc.c usbd_desc.h usbh_conf.h app_ethernet.cpp ethernetif.cpp stm32f2xx_hal_msp.cpp stm32f2xx_it.cpp usbd_cdc_interface.cpp usbd_conf.cpp usbh_conf.cpp
  group src
    ./Device53/: check.bat defines.h err.txt Globals.h includes.txt Log.h main.h main2.s Tables.h Device53.sct Globals.cpp Log.cpp main.cpp Tables.cpp stub.cpp stub.h
    ../common/: commonDefines.h commonDefines.cpp
  group Display
    ./Device53/Display/: Display.cpp Display.h PainterMem.h Symbols.h PainterMem.cpp
    ../common/Display/: Colors.cpp Colors.h Grid.cpp Grid.h Painter.cpp Painter.h PainterText.cpp DisplayPrimitives.cpp DisplayPrimitives.h
  group Display/font
    ./Device53/Display/font/: Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc Font.cpp
  group Ethernet
    ./Device53/Ethernet/: Ethernet.h TcpSocket.h Ethernet.cpp TcpSocket.cpp
  group FlashDrive
    ./Device53/FlashDrive/: FlashDrive.cpp FlashDrive.h
  group FPGA
    ./Device53/FPGA/: DataStorage.cpp DataStorage.h FPGA.cpp FPGA.h FPGACalibration.cpp FPGASettings.cpp FPGATypes.h
    ../common/FPGA/: FPGAMath.cpp FPGAMath.h
  group Hardware
    ./Device53/Hardware/: ADC.cpp ADC.h DisplayHardware.inc FLASH.h FSMC.h Hardware.h RTC.cpp RTC.h Sound.cpp Sound.h FLASH.cpp FSMC.cpp Hardware.cpp MSP_USBH.cpp
    ../common/Hardware/: Timer.cpp Timer.h
  group Menu
    ./Device53/Menu/: FileManager.h FileManager.cpp
    ../common/Menu/: Menu.cpp Menu.h MenuDrawing.cpp MenuDrawing.h MenuFunctions.cpp MenuFunctions.h MenuItems.cpp MenuItems.h MenuItemsDefs.h MenuItemsGraphics.cpp MenuItemsLogic.cpp
  group Menu/Pages
    ./Device53/Menu/Pages/: HelpContent.h HelpContentPages.h PageCursors.h PageHelp.h PageMemory.h HelpContent.cpp PageChannels.cpp PageCursors.cpp PageDebug.cpp PageDisplay.cpp PageHelp.cpp PageMeasures.cpp PageMemory.cpp PageService.cpp PageTime.cpp PageTrig.cpp
    ../common/Menu/Pages/: Definition.cpp Definition.h
  group Panel
    ./Device53/Panel/: Controls.h Panel.cpp Panel.h Controls.cpp PanelFunctions.cpp
  group Settings
    ./Device53/Settings/: Settings.h SettingsChannel.h SettingsCursors.h SettingsDebug.h SettingsDisplay.h SettingsMath.h SettingsMeasures.h SettingsMemory.h SettingsService.h SettingsTime.h SettingsTrig.h SettingsTypes.h Settings.cpp SettingsChannel.cpp SettingsCursors.cpp SettingsDebug.cpp SettingsDisplay.cpp SettingsMeasures.cpp SettingsMemory.cpp SettingsService.cpp SettingsTime.cpp
    ../common/Settings/: commonSettings.cpp commonSettingsMath.h
  group Utils
    ./Device53/Utils/: ProcessingSignal.h ProcessingSignal.cpp
    ../common/Utils/: Math.cpp Math.h StringUtils.cpp StringUtils.h Dictionary.cpp Dictionary.h CommonFunctions.cpp CommonFunctions.h Map.cpp Map.h Measures.cpp Measures.h
  group VCP
    ./Device53/VCP/: VCP.h VCP.cpp
  group VCP/SCPI
    ./Device53/VCP/SCPI/: commonSCPI.h controlSCPI.h SCPI.h channelSCPI.cpp commonSCPI.cpp controlSCPI.cpp displaySCPI.cpp SCPI.cpp tbaseSCPI.cpp trigSCPI.cpp
  group FatFS
    ../_libs/STM32Cube_F2/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../_libs/STM32Cube_F2/Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c usbh_diskio.h
    ../_libs/STM32Cube_F2/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group USBD
    ../_libs/STM32Cube_F2/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../_libs/STM32Cube_F2/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
